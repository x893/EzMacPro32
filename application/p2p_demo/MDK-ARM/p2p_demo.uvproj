# Keil uVision project p2p_demo.uvproj, settings and files
target STM32-fwd_node (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-fwd_node
  c flags: Optim=2 OneElfS=1
  c define: FWD_NODE STM32F10X_MD USE_STDPERIPH_DRIVER FREQUENCY_BAND_868 TRANSCEIVER_OPERATION FOUR_CHANNEL_IS_USED EXTENDED_PACKET_FORMAT PACKET_FORWARDING_SUPPORTED
  c include: ..\..\..\bsp;..\..\..\stack;..\..\..\port\stm32;..\..\..\port\stm32\CMSIS\CM3\CoreSupport;..\..\..\port\stm32\STM32F10x_StdPeriph_Driver\inc;..\..\..\port\stm32\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group application
    ../: main.c p2p_demo_callbacks.c p2p_demo_fwd_menu.c p2p_demo_fwd_node.c p2p_demo_rx_menu.c p2p_demo_rx_node.c p2p_demo_tx_menu.c p2p_demo_tx_node.c
  group stack
    ../../../stack/: EZMacPro.c EZMacPro_Const.c EZMacPro_ExternalInt.c EZMacPro_TimerInt.c
  group bsp
    ../../../bsp/: bsp.c graphics.c si443x_const_b1.c si4431_const_a0.c si4432_const_v2.c STARTUP.A51
  group bsp-STM32
    ../../../port/stm32/: bsp_user.c spi.c system_stm32f10x.c timer.c uart.c bsp_gpio.h hardware_defs.h spi.h stm32f10x_conf.h timer.h uart.h
  group STM32
    ../../../port/stm32/: system_stm32f10x.c startup_stm32f10x_md.s stm32f10x_conf.h
    ../../../port/stm32/STM32F10x_StdPeriph_Driver/src/: stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c misc.c
target STM32-rx_node (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: STM32-rx_node
  c flags: Optim=2 OneElfS=1
  c define: RX_NODE STM32F10X_MD USE_STDPERIPH_DRIVER FREQUENCY_BAND_868 TRANSCEIVER_OPERATION FOUR_CHANNEL_IS_USED EXTENDED_PACKET_FORMAT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32-tx_node (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: STM32-tx_node
  c flags: Optim=2 OneElfS=1
  c define: TX_NODE STM32F10X_MD USE_STDPERIPH_DRIVER FREQUENCY_BAND_868 TRANSCEIVER_OPERATION FOUR_CHANNEL_IS_USED EXTENDED_PACKET_FORMAT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
