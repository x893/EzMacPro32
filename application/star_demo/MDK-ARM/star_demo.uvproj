# Keil uVision project star_demo.uvproj, settings and files
target STM32-master (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-master
  c flags: Optim=2 OneElfS=1
  c define: MASTER_NODE STM32F10X_MD USE_STDPERIPH_DRIVER FREQUENCY_BAND_915 TRANSCEIVER_OPERATION FOUR_CHANNEL_IS_USED EXTENDED_PACKET_FORMAT
  c include: ..\..\..\bsp;..\..\..\stack;..\..\..\port\stm32;..\..\..\port\stm32\CMSIS\CM3\CoreSupport;..\..\..\port\stm32\STM32F10x_StdPeriph_Driver\inc;..\..\..\port\stm32\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group application
    ../: main.c star_demo_master_callbacks.c star_demo_master_menu.c star_demo_master_node.c star_demo_slave_callbacks.c star_demo_slave_node.c
  group stack
    ../../../stack/: EZMacPro.c EZMacPro_Const.c EZMacPro_ExternalInt.c EZMacPro_TimerInt.c
  group bsp
    ../../../bsp/: bsp.c graphics.c si443x_const_b1.c si4431_const_a0.c si4432_const_v2.c STARTUP.A51
  group bsp-STM32
    ../../../port/stm32/: bsp_user.c spi.c system_stm32f10x.c timer.c uart.c bsp_gpio.h hardware_defs.h spi.h stm32f10x_conf.h timer.h uart.h
  group STM32
    ../../../port/stm32/: system_stm32f10x.c startup_stm32f10x_md.s stm32f10x_conf.h
    ../../../port/stm32/STM32F10x_StdPeriph_Driver/src/: stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c misc.c
target STM32-slave (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: STM32-slave
  c flags: Optim=2 OneElfS=1
  c define: SLAVE_NODE STM32F10X_MD USE_STDPERIPH_DRIVER FREQUENCY_BAND_915 TRANSCEIVER_OPERATION FOUR_CHANNEL_IS_USED EXTENDED_PACKET_FORMAT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target EZLINK-master (MCS-51)
  device: C8051F930 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: EZLINK-master +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: MASTER_NODE EZLINK FREQUENCY_BAND_915 TRANSCEIVER_OPERATION FOUR_CHANNEL_IS_USED EXTENDED_PACKET_FORMAT
  c misc: DB OE
  c include: ..\..\..\bsp;..\..\..\stack;..\..\..\..\MCU\INC;..\..\..\port\silabs
  asm misc: GEN DB
  link misc: REMOVEUNUSED
target EZLINK_slave (MCS-51)
  device: C8051F930 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: EZLINK-slave +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: SLAVE_NODE EZLINK FREQUENCY_BAND_915 TRANSCEIVER_OPERATION FOUR_CHANNEL_IS_USED EXTENDED_PACKET_FORMAT
  c misc: DB OE
  c include: as above
  asm misc: GEN DB
  link misc: REMOVEUNUSED
